FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
	file://0000-ddr_param_def_lpddr4-rzv2n_1.patch \
"
